# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\..\source\third_party\CMSIS\Core\Include;..\..\..\source;..\bsp;..\..\v2.1-bfs;..\v2.0-bfs;..\..\..\mspm0_sdk_1_30_00_03\mspm0_sdk_1_30_00_03\source;..\..\..\mspm0_sdk_1_30_00_03\mspm0_sdk_1_30_00_03\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: D:\Ti\mspm0_sdk_1_30_00_03\mspm0_sdk_1_30_00_03\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c empty.c
    ./: startup_mspm0g350x_uvision.s
  group bsp
    ../bsp/: Key.c Key.h board.c board.h Motor.c Motor.h PWM.c PWM.h OLED.c OLED.h OLED_Font.h bfs.c bfs.h bsp_bluetooth.c bsp_bluetooth.h bsp_uart.c bsp_uart.h Encoder.c Encoder.h No_Mcu_Ganv_Grayscale_Sensor.c No_Mcu_Ganv_Grayscale_Sensor_Config.h GW_ADC.c GW_ADC.h GW_Time.c GW_Time.h JY60.c JY60.h JY60_USART.c JY60_USART.h
    ../: wit_c_sdk.h wit_c_sdk.c
    ./: k230_receiver.c k230_receiver.h
